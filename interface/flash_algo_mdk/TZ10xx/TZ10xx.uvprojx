# Keil uVision project TZ10xx.uvprojx, settings and files
target TZ10xx (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ELITTLE
  output: flash_algo
  AfterMake: cmd.exe /C copy out\flash_algo.axf ..\..\..\tools\tmp
  AfterMake: cmd.exe /C ..\..\..\tools\flash_algo_gen.py
  c flags: Optim=3
  c define: USE_SPIFI_LIB, ENABLE_QUAD
  c misc: --diag_suppress 3017
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
